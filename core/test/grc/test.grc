blocks:
- name: main_source
  id: good::fixed_source
  parameters:
    event_count: '100'
    unknown_property: '42'
  states: {}
- name: multiplier
  id: good::multiply
  parameters: {}
  states: {}
- name: counter
  id: builtin_counter
  parameters: {}
  states: {}
- name: sink
  id: good::cout_sink
  parameters:
    total_count: '100'
    unknown_property: '42'
  states: {}

connections:
- [main_source, '0', multiplier, '0']
- [multiplier, '0', counter, '0']
- [counter, '0', sink, '0']

metadata:
  file_format: 1
